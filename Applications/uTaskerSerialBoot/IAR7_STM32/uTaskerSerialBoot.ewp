# IAR project uTaskerSerialBoot.ewp, settings and files
configuration FLASH (ARM)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: _STM32; COMPILE_IAR
  ICCARM.CCIncludePath2: .; ..\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uTaskerSerialBoot.bin
  ILINK.IlinkOutputFile: uTaskerSerialBoot.out
  ILINK.IlinkIcfFile: settings\uTaskerSTM32_64_20.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _COMPILE_IAR; _KINETIS
  OBJCOPY.OOCOutputFile: uTaskerSerialBoot.srec
  ILINK.IlinkIcfFile: settings\K_128.icf
  group (top)
    ../: app_hw_STM32.h config.h disk_loader.c Loader.h serial_loader.c TaskConfig.h types.h usb_application.c usb_device_loader.c usb_host_loader.c webInterface.c
  group Hardware
    ../../../Hardware/STM32/: STM32.c
  group TCP/IP
    ../../../stack/: arp.c Ethernet.c http.c icmp.c ip.c ip_utils.c tcp.c webutils.c
  group TCP/IP/SSL/mbedtls-1.3.10
    ../../../stack/SSL/mbedtls-1.3.10/: aes_mbedTLS.c
  group uTasker
    ../../../uTasker/: crypto.c Driver.c eth_drv.c i2c_drv.c Tty_drv.c uFile.c uMalloc.c USB_drv.c uTasker.c Watchdog.c
  group uTasker/uGLCDLIB
    ../../../uTasker/uGLCDLIB/: GLCD.c
  group uTasker/utFAT
    ../../../uTasker/utFAT/: mass_storage.c mass_storage.h
