# Keil uVision project uTaskerSerialBoot.uvprojx, settings and files
target uTasker_serial_boot (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MK64FN1M0xxx12 Freescale
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uTaskerSerialBoot +hex
  AfterMake: Make-Binary.bat
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: _COMPILE_KEIL, _KINETIS
  c include: ..\
  asm define: CORTEX_M4
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: settings/K_1M_256.sct
  link misc: --entry main
--keep=reset_vect
  group uTasker
    ../../../uTasker/: Driver.c Tty_drv.c uFile.c uMalloc.c uTasker.c Watchdog.c USB_drv.c eth_drv.c
  group Source Files
    ../: webInterface.c usb_application.c usb_device_loader.c usb_host_loader.c serial_loader.c disk_loader.c
  group Header Files
    ../: app_hw_kinetis.h config.h Loader.h TaskConfig.h types.h
  group Hardware
    ../../../Hardware/Kinetis/: kinetis.c kinetis.h kinetis_asm.s
  group utFAT
    ../../../uTasker/utFAT/: mass_storage.c
  group TCP/IP
    ../../../stack/: ip_utils.c arp.c Ethernet.c http.c icmp.c ip.c tcp.c webutils.c
