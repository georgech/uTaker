# IAR project uTaskerV1.4.ewp, settings and files
configuration Flash (ARM)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 NXP MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _KINETIS; _COMPILE_IAR
  ICCARM.CCIncludePath2: .; ..\; ..\..\..\FreeRTOS\Source\include; ..\..\..\FreeRTOS\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uTaskerV1.4.bin
  ILINK.IlinkOutputFile: uTaskerV1.4.out
  ILINK.IlinkIcfFile: settings\K_1M_256.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK70FN1M0xxx12 Freescale MK70FN1M0xxx12
  ICCARM.CCDefines: _COMPILE_IAR; _KINETIS
  ICCARM.CCIncludePath2: .; ..\
  ICCARM.CCOptLevel: 2
  OBJCOPY.OOCOutputFile: uTaskerV1.4.srec
  ILINK.IlinkIcfFile: settings\K_128.icf
configuration Flash_BM (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: .; ..\
  OBJCOPY.OOCOutputFile: uTaskerV1.4_BM.bin
  ILINK.IlinkOutputFile: uTaskerV1.4_BM.out
  ILINK.IlinkIcfFile: settings\K_1M_256_BM.icf
  group (top)
    ../: application.c debug.c FreeRTOSapplication.c KeyScan.c modbus_app.c NetworkIndicator.c snmp_mib_handlers.c usb_application.c webInterface.c
  group FreeRTOS
    ../../../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/portableM0
    ../../../FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group FreeRTOS/portableM4F
    ../../../FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Hardware
    ../../../Hardware/Kinetis/: kinetis.c
  group TCP/IP
    ../../../stack/: arp.c dhcp.c dns.c Ethernet.c ftp.c ftp_client.c http.c icmp.c igmp.c ip.c ip_utils.c NetBIOS.c pop3.c ppp.c smtp.c snmp.c tcp.c tcpip.h telnet.c tftp.c udp.c webutils.c zero_config.c
  group TCP/IP/mbedtls
    ../../../stack/SSL/mbedtls-1.3.10/: aes.c
  group TCP/IP/OpenSSL
    ../../../stack/SSL/openssl-1.0.2/: aes_cbc.c aes_core.c cbc128.c
  group TCP/IP/wolfSSL
    ../../../stack/SSL/wolfssl-3.9.6/: w_aes.c
  group uTasker
    ../../../uTasker/: can_drv.c crypto.c Driver.c DSP.c eth_drv.c GlobalTimer.c i2c_drv.c low_power.c SSC_drv.c time_keeper.c Tty_drv.c uFile.c uMalloc.c uNetwork.c USB_drv.c uTasker.c Watchdog.c
  group uTasker/MODBUS
    ../../../uTasker/MODBUS/: MODBUS.c modbus.h
  group uTasker/uGLCDLIB
    ../../../uTasker/uGLCDLIB/: GLCD.c glcd.h glcd_cglcd.h glcd_fonts.h glcd_nokia.h glcd_oled.h glcd_samsung.h glcd_tft.h glcd_toshiba.h LCD.c
  group uTasker/utFAT
    ../../../uTasker/utFAT/: mass_storage.c mass_storage.h NAND_driver.h
