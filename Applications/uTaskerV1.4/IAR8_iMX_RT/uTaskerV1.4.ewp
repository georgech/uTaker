# IAR project uTaskerV1.4.ewp, settings and files
configuration Flash (ARM)
  General.OGChipSelectEditMenu: MIMXRT1021xxx5A NXP MIMXRT1021xxx5A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: _iMX; _COMPILE_IAR
  ICCARM.CCIncludePath2: .; ..\; ..\..\..\FreeRTOS\Source\include; ..\..\..\FreeRTOS\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uTaskerV1.4.bin
  ILINK.IlinkOutputFile: uTaskerV1.4.out
  ILINK.IlinkIcfFile: settings\iMX_RT_1020_FlexSPI_NOR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: _COMPILE_IAR; _iMX
  ICCARM.CCIncludePath2: .; ..\; ..\..\..\FreeRTOS\Source\include; ..\..\..\FreeRTOS\Sourceportable\IAR\ARM_CF4F
  ICCARM.CCOptLevel: 2
  OBJCOPY.OOCOutputFile: uTaskerV1.4.srec
  ILINK.IlinkIcfFile: settings\iMX_RT_1020_SRAM.icf
configuration Flash_BM (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK28FN2M0xxx15 NXP MK28FN2M0xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _KINETIS; _COMPILE_IAR
  OBJCOPY.OOCOutputFile: uTaskerV1.4_BM.bin
  ILINK.IlinkOutputFile: uTaskerV1.4_BM.out
  ILINK.IlinkIcfFile: settings\K_2M_1M_BM.icf
  group (top)
    ../: application.c debug.c DMX512.c FreeMaster.c FreeRTOSapplication.c KeyScan.c modbus_app.c NetworkIndicator.c snmp_mib_handlers.c uCANopenApp.c usb_application.c webInterface.c
  group FreeRTOS
    ../../../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/portableM0
    ../../../FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group FreeRTOS/portableM4F
    ../../../FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Hardware
    ../../../Hardware/iMX/: iMX.c
  group TCP/IP
    ../../../stack/: arp.c dhcp.c dns.c Ethernet.c ftp.c ftp_client.c http.c icmp.c igmp.c ip.c ip_utils.c mqtt.c NetBIOS.c pop3.c ppp.c secure_layer.c smtp.c snmp.c tcp.c tcpip.h telnet.c tftp.c udp.c webutils.c zero_config.c
  group TCP/IP/mbedtls
    ../../../stack/SSL/mbedtls-1.3.10/: aes_mbedTLS.c sha256_mbedTLS.c
  group TCP/IP/OpenSSL
    ../../../stack/SSL/openssl-1.0.2/: aes_cbc.c aes_core.c cbc128.c
  group TCP/IP/wolfSSL
    ../../../stack/SSL/wolfssl-3.9.6/: w_aes.c
  group Test/LTC_AES
    ../../../NXP/LTC_TEST/: ltc_aes.c
  group uTasker
    ../../../uTasker/: can_drv.c crypto.c Driver.c DSP.c eth_drv.c GlobalTimer.c i2c_drv.c low_power.c SPI_drv.c SSC_drv.c time_keeper.c Tty_drv.c uFile.c uMalloc.c uNetwork.c USB_drv.c uTasker.c Watchdog.c
  group uTasker/MODBUS
    ../../../uTasker/MODBUS/: MODBUS.c modbus.h
  group uTasker/uCANopen
    ../../../uTasker/uCANopen/: CANopen.c CO_driver.c CO_Emergency.c CO_HBconsumer.c CO_NMT_Heartbeat.c CO_PDO.c CO_SDO.c CO_SDOmaster.c CO_SYNC.c crc16-ccitt.c
  group uTasker/uGLCDLIB
    ../../../uTasker/uGLCDLIB/: GLCD.c glcd.h glcd_cglcd.h glcd_fonts.h glcd_nokia.h glcd_oled.h glcd_samsung.h glcd_tft.h glcd_toshiba.h LCD.c
  group uTasker/utFAT
    ../../../uTasker/utFAT/: mass_storage.c mass_storage.h NAND_driver.h
