# Keil uVision project uTaskerBoot.uvprojx, settings and files
target uTaskerBootLoader (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uTaskerBoot +hex
  AfterMake: Make-Binary.bat
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: _COMPILE_KEIL, _STM32
  c include: ..\
  asm define: CORTEX_M0
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\settings\STM32F4_1M_196.sct
  link misc: --entry main
--keep=reset_vect
  group Source Files
    ../: uTaskerBootLoader.c
  group Header Files
    ../: config.h types.h
  group Hardware
    ../../../Hardware/STM32/: STM32_boot.c STM32_keil_asm.s
  group SPI_memory
    ../../../Hardware/SPI_Memory/: spi_eeprom_25AA160.h spi_flash_interface.h spi_flash_kinetis_atmel.h spi_flash_kinetis_sst25.h spi_flash_kinetis_stmicro.h spi_flash_MX25L.h spi_flash_s25fl1-k.h spi_flash_STM32_atmel.h spi_flash_STM32_MX66L.h spi_flash_STM32_sst25.h spi_flash_STM32_stmicro.h spi_flash_w25q.h
