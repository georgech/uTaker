# IAR project uTaskerBoot.ewp, settings and files
configuration Debug STM32 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: COMPILE_IAR; _STM32
  ICCARM.CCIncludePath2: .; ..\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uTaskerBoot.bin
  ILINK.IlinkOutputFile: uTaskerBoot.out
  ILINK.IlinkIcfFile: settings\STM32_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release STM32 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: _STM32; COMPILE_IAR
  ILINK.IlinkIcfFile: settings\STM32_F4_Flash.icf
  group (top)
    ../: uTaskerBootLoader.c
  group Hardware
    ../../../Hardware/STM32/: STM32_boot.c
