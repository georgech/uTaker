# IAR project uTaskerBoot.ewp, settings and files
configuration uTaskerBoot - Flash (ARM)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 NXP MK64FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _KINETIS; _COMPILE_IAR
  ICCARM.CCIncludePath2: .; ..\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uTaskerBoot.bin
  ILINK.IlinkOutputFile: uTaskerBoot.out
  ILINK.IlinkIcfFile: settings\K_1M_256.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: config.h types.h uTaskerBootLoader.c
  group Hardware
    ../../../Hardware/Kinetis/: kinetis.h kinetis_boot.c spi_flash_kinetis_atmel.h spi_flash_kinetis_sst25.h spi_flash_kinetis_stmicro.h
